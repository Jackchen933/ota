# Keil uVision project template.uvprojx, settings and files
target STM32F4x1 (6190000::V6.19::ARMCLANG)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Bootloder
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,STM32F411xE
  c include: ..\MDK-ARM;..\Core\Inc;..\Drivers\STM32F4xx_StdPeriph_Driver\inc;..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Middlewares\RTT;..\Drivers\CMSIS\Include;..\Middlewares\easylogger\inc;..\Tasks\Debug;..\Tasks\Boot_Manager;..\Middlewares\Ymodem;..\Middlewares\AES\Algorithms\inc;..\Bsp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/User/Core
    ../Core/Src/: main.c tim.c gpio.c stm32f4xx_it.c usart.c Flash.c w25qxx.c W25Q_Handler.c Eeprom.c
    ../Core/Inc/: stm32f4xx_conf.h
  group Application/MDK-ARM
    ./: startup_stm32f401xx.s startup_stm32f411xe.s
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_StdPeriph_Driver
    ../Drivers/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Middlewares/RTT
    ../Middlewares/RTT/: SEGGER_RTT_Conf.h SEGGER_RTT_printf.c SEGGER_RTT.c SEGGER_RTT.h
  group Middlewares/easylogger
    ../Middlewares/easylogger/port/: elog_port.c
    ../Middlewares/easylogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
  group Tasks/Debug
    ../Tasks/Debug/: Debug.c
  group Tasks/Boot_Manager
    ../Tasks/Boot_Manager/: Boot_Manager.c FlagSector.c md5.c
  group Middlewares/Ymodem
    ../Middlewares/Ymodem/: ymodem.c common.c
  group Middlewares/AES
    ../Middlewares/AES/Algorithms/src/: aes.c
  group Bsp
    ../Bsp/: Spi.c
software components: CMSIS:CORE 5.6.0
