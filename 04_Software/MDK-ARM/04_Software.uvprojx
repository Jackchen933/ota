# Keil uVision project 04_Software.uvprojx, settings and files
target 04_Software (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: 04_Software +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE,LV_CONF_INCLUDE_SIMPLE
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../USERS/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares;../Middlewares/lvgl;../UI;../UI/Inc;../UI/custom;../UI/generated;../UI/generated/screens;../UI/generated/events;../UI/assets/fonts;../UI/assets/images;../BSP/Inc
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x800c000 size 0x74000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c i2c.c dma.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_i2c.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group USERS
    ../USERS/Src/: OtaApp.c W25q64.c Eeprom.c OtaFlag.c
  group BSP
    ../BSP/Src/: bsp_st7789.c bsp_st7789_port.c bsp_cst816s.c screen_hw.c bsp_i2c1_bus.c
  group LVGL/core
    ../Middlewares/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
    ../Middlewares/lvgl/src/display/: lv_display.c
    ../Middlewares/lvgl/src/indev/: lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
    ../Middlewares/lvgl/src/: lv_init.c
    ../Middlewares/lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
    ../Middlewares/lvgl/src/tick/: lv_tick.c
  group LVGL/draw
    ../Middlewares/lvgl/src/draw/convert/: lv_draw_buf_convert.c
    ../Middlewares/lvgl/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../Middlewares/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ../Middlewares/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
  group LVGL/font
    ../Middlewares/lvgl/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
  group LVGL/misc
    ../Middlewares/lvgl/src/layouts/flex/: lv_flex.c
    ../Middlewares/lvgl/src/layouts/grid/: lv_grid.c
    ../Middlewares/lvgl/src/layouts/: lv_layout.c
    ../Middlewares/lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    ../Middlewares/lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../Middlewares/lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../Middlewares/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_profiler_builtin_posix.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../Middlewares/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../Middlewares/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../Middlewares/lvgl/src/stdlib/: lv_mem.c
    ../Middlewares/lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
    ../Middlewares/lvgl/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    ../Middlewares/lvgl/src/stdlib/uefi/: lv_mem_core_uefi.c
  group LVGL/widgets
    ../Middlewares/lvgl/src/widgets/arc/: lv_arc.c
    ../Middlewares/lvgl/src/widgets/bar/: lv_bar.c
    ../Middlewares/lvgl/src/widgets/button/: lv_button.c
    ../Middlewares/lvgl/src/widgets/chart/: lv_chart.c
    ../Middlewares/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../Middlewares/lvgl/src/widgets/image/: lv_image.c
    ../Middlewares/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../Middlewares/lvgl/src/widgets/label/: lv_label.c
    ../Middlewares/lvgl/src/widgets/led/: lv_led.c
    ../Middlewares/lvgl/src/widgets/line/: lv_line.c
    ../Middlewares/lvgl/src/widgets/slider/: lv_slider.c
    ../Middlewares/lvgl/src/widgets/spinner/: lv_spinner.c
    ../Middlewares/lvgl/src/widgets/switch/: lv_switch.c
    ../Middlewares/lvgl/src/widgets/table/: lv_table.c
    ../Middlewares/lvgl/src/widgets/arclabel/: lv_arclabel.c
  group LVGL/themes
    ../Middlewares/lvgl/src/themes/default/: lv_theme_default.c
    ../Middlewares/lvgl/src/themes/: lv_theme.c
    ../Middlewares/lvgl/src/themes/mono/: lv_theme_mono.c
    ../Middlewares/lvgl/src/themes/simple/: lv_theme_simple.c
  group LVGL/others
    ../Middlewares/lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
    ../Middlewares/lvgl/src/others/observer/: lv_observer.c
  group UI
    ../UI/Src/: lv_port_disp.c ui_test.c lv_port_indev.c lvgl_task.c
  group GUI Guider
    ../UI/generated/: gg_utils.c
    ../UI/generated/screens/: gg_screen.c gg_layer_sys.c gg_layer_top.c gg_layer_bottom.c gg_screen_1.c gg_screen_2.c gg_screen_3.c gg_screen_4.c
    ../UI/generated/events/: gg_event_screen.c gg_event_layer_sys.c gg_event_layer_top.c gg_event_layer_bottom.c gg_event_screen_1.c gg_event_screen_2.c gg_event_screen_3.c gg_event_screen_4.c
    ../UI/custom/: custom.c
  group UI/Assets
    ../UI/assets/fonts/: lv_font_alimama_14.c lv_font_alimama_30.c lv_font_digitaldreamfatnarrow_30.c lv_font_interttf_30.c lv_font_interttf_40.c lv_font_montserratMedium_10.c lv_font_montserratMedium_20.c
    ../UI/assets/images/: BT32_35x36_RGB565A8.c BT32_39x37_RGB565A8.c Ellipse_30x26_RGB565A8.c KLL16x16_21x16_RGB565A8.c MDLBG_120x140_RGB565A8.c ZNZBG_50x50_RGB565A8.c biaopan1_91x76_RGB565A8.c heart16x16_29x29_RGB565A8.c liangdu_43x36_RGB565A8.c location32x32_31x34_RGB565A8.c location32x32_32x32_RGB565A8.c location_47x38_RGB565A8.c mianti_0_36x34_RGB565A8.c nfc_47x38_RGB565A8.c pa_30x23_RGB565A8.c power_hight_50x28_RGB565A8.c taiwan_47x38_RGB565A8.c time_57x11_RGB565A8.c time_70x14_RGB565A8.c tiwen_34x32_RGB565A8.c weater32x32_50x39_RGB565A8.c zhengdong_0_33x33_RGB565A8.c
software components: CMSIS:CORE 4.3.0
